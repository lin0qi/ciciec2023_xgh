# Keil uVision project test1.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: CMSDK_CM0 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.8.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: test1 +hex
  AfterMake: fromelf -cvf .\Objects\test1.axf --vhx --32x1 -o .\Objects\test1.hex
  AfterMake: fromelf -cvf .\Objects\test1.axf -o test1.txt
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./startup/: startup_CMSDK_CM0.s
